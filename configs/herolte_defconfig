## configs/herolte_defconfig
```kconfig
CONFIG_CROSS_COMPILE="aarch64-linux-gnu-"
CONFIG_EXYNOS_8890=y
CONFIG_SAMSUNG_HEROLTE=y
```
